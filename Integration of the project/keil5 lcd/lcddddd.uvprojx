# Keil uVision project lcddddd.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lcddddd
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: DIO.c lcd.h main.c MCAL.h Port_Init.c Port_SetPinDirection.c tm4c123gh6pm.h delay.c delay.h itoa.c LCD_clearScreen.c LCD_displayCharacter.c LCD_displayString.c LCD_displayStringRowColumn.c LCD_goToRowColumn.c LCD_Init.c LCD_intgerToString.c LCD_sendCommand.c typedefs.h button.h Button_Decrement.c Button_Increment.c Button_Reset.c Port_SetPinPullUp.c Port_SetPinPullDown.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
